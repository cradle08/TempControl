# Keil uVision project Stm32f3xx_Global_Project.uvprojx, settings and files
target Stm32f4xx_uCOSIII_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F302RE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MGISP-s8_TempControl_App_ +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Outputs/MGISP-s8_TempControl_App_.bin ../ProjectOutputs/MGISP-s8_TempControl_App_.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302xE
  c misc: --C99
  c include: ..\CMSIS\Include;..\CMSIS\Device\ST\STM32F3xx\Include;..\STM32F3xx_HAL_Driver\Inc;..\SystemCfg;..\SystemBsp;..\Utilities;..\Middlewares\uC-CPU;..\Middlewares\uC-LIB;..\Middlewares\uC-PORT;..\Middlewares\uCOS-III;..\Application;..\Application\device
  memory RVCT4: ROM 0x8010000 size 0x2f800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../SystemCfg/: main.c
    ../Application/: example.c loopBuff.c includes.h crc.c protocolDeal.c uartTask.c spiTask.c mainHandle.c timTask.c i2cTask.c peripheralInit.c TECdeal.c flash_if.c eepromDeal.c
  group SystemCfg
    ../SystemCfg/: stm32f3xx_hal_conf.h stm32f3xx_it.c stm32f3xx_it.h startup_stm32f302xe.s
  group SystemBsp
    ../SystemBsp/: bsp_common.h bsp_common.c bsp_msp_port.c bsp_msp_port.h stm32f3xx_hal_msp.c stm32f3xx_hal_msp.h
  group STM32F3xx_HAL_Driver/Inc
    ../STM32F3xx_HAL_Driver/Inc/: stm32_assert_template.h stm32f3xx_hal.h stm32f3xx_hal_adc.h stm32f3xx_hal_adc_ex.h stm32f3xx_hal_can.h stm32f3xx_hal_cec.h stm32f3xx_hal_comp.h stm32f3xx_hal_comp_ex.h stm32f3xx_hal_conf_template.h stm32f3xx_hal_cortex.h stm32f3xx_hal_crc.h stm32f3xx_hal_crc_ex.h stm32f3xx_hal_dac.h stm32f3xx_hal_dac_ex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_hrtim.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_i2s.h stm32f3xx_hal_i2s_ex.h stm32f3xx_hal_irda.h stm32f3xx_hal_irda_ex.h stm32f3xx_hal_iwdg.h stm32f3xx_hal_nand.h stm32f3xx_hal_nor.h stm32f3xx_hal_opamp.h stm32f3xx_hal_opamp_ex.h stm32f3xx_hal_pccard.h stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_rtc.h stm32f3xx_hal_rtc_ex.h stm32f3xx_hal_sdadc.h stm32f3xx_hal_smartcard.h stm32f3xx_hal_smartcard_ex.h stm32f3xx_hal_smbus.h stm32f3xx_hal_spi.h stm32f3xx_hal_spi_ex.h stm32f3xx_hal_sram.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h stm32f3xx_hal_tsc.h stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.h stm32f3xx_hal_usart.h stm32f3xx_hal_usart_ex.h stm32f3xx_hal_wwdg.h stm32f3xx_ll_adc.h stm32f3xx_ll_bus.h stm32f3xx_ll_comp.h stm32f3xx_ll_cortex.h stm32f3xx_ll_crc.h stm32f3xx_ll_dac.h stm32f3xx_ll_dma.h stm32f3xx_ll_exti.h stm32f3xx_ll_fmc.h stm32f3xx_ll_gpio.h stm32f3xx_ll_hrtim.h stm32f3xx_ll_i2c.h stm32f3xx_ll_iwdg.h stm32f3xx_ll_opamp.h stm32f3xx_ll_pwr.h stm32f3xx_ll_rcc.h stm32f3xx_ll_rtc.h stm32f3xx_ll_spi.h stm32f3xx_ll_system.h stm32f3xx_ll_tim.h stm32f3xx_ll_usart.h stm32f3xx_ll_utils.h stm32f3xx_ll_wwdg.h
  group STM32F3xx_HAL_Driver/Scr
    ../STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_msp_template.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_fmc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_opamp.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
  group CMSIS
    ../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    ../CMSIS/Device/ST/STM32F3xx/Include/: stm32f3xx.h system_stm32f3xx.h
    ../CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group device
    ../Application/device/: eeprom.c gpio.c PID.c protocolAnalysis_app.c temperature_control.c AD7124_temp.c AD7124.c appTest.c loopBuff4b.c
    ../Application/: Version.c
